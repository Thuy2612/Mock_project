# IAR project Assignment_5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: ..\Application\Inc; ..\Board\Inc; ..\Board\Startup\CMSIS\Include; ..\Board\Startup\MKL46Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Assignment_5.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../Application/: main.c
  group Application/Include
    ../Application/Inc/: App.h Queue.h Srec_parse.h UART0.h
  group Application/Source
    ../Application/Src/: App.c Queue.c Srec_parse.c UART0.c
  group Board/Startup/CMSIS
    ../Board/Startup/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group Board/Startup/MKL46
    ../Board/Startup/MKL46Z/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
